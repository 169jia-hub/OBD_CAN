# Keil uVision project OBD_CAN.uvprojx, settings and files
target OBD_CAN (5060960::V5.06 update 7 (build 960)::.\arm5_compiler)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: OBD_CAN
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../OBD_UI_Code;../OBD_UI_Code/lvgl;../Touch
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: fonts.c bsp_ili9806g_lcd.c main.c gpio.c can.c dma.c fsmc.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group LVGL_UI
    ../OBD_UI_Code/: ui.c ui_helpers.c
    ../OBD_UI_Code/components/: ui_comp_hook.c
    ../OBD_UI_Code/images/: ui_img_235150827.c ui_img_antilock_brake_fault_png.c ui_img_icon_teld_engine_png.c
    ../OBD_UI_Code/screens/: ui_Screen1.c ui_ScreenDiag.c
  group LVGL_SRC
    ../OBD_UI_Code/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../OBD_UI_Code/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../OBD_UI_Code/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../OBD_UI_Code/lvgl/src/extra/: lv_extra.c
    ../OBD_UI_Code/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../OBD_UI_Code/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../OBD_UI_Code/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../OBD_UI_Code/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../OBD_UI_Code/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../OBD_UI_Code/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../OBD_UI_Code/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../OBD_UI_Code/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../OBD_UI_Code/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../OBD_UI_Code/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../OBD_UI_Code/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../OBD_UI_Code/lvgl/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../OBD_UI_Code/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../OBD_UI_Code/lvgl/src/extra/others/ime/: lv_ime_pinyin.c
    ../OBD_UI_Code/lvgl/src/extra/others/imgfont/: lv_imgfont.c
    ../OBD_UI_Code/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../OBD_UI_Code/lvgl/src/extra/others/msg/: lv_msg.c
    ../OBD_UI_Code/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../OBD_UI_Code/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../OBD_UI_Code/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../OBD_UI_Code/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../OBD_UI_Code/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../OBD_UI_Code/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../OBD_UI_Code/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../OBD_UI_Code/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../OBD_UI_Code/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../OBD_UI_Code/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../OBD_UI_Code/lvgl/src/extra/widgets/led/: lv_led.c
    ../OBD_UI_Code/lvgl/src/extra/widgets/list/: lv_list.c
    ../OBD_UI_Code/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../OBD_UI_Code/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../OBD_UI_Code/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../OBD_UI_Code/lvgl/src/extra/widgets/span/: lv_span.c
    ../OBD_UI_Code/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../OBD_UI_Code/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../OBD_UI_Code/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../OBD_UI_Code/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../OBD_UI_Code/lvgl/src/extra/widgets/win/: lv_win.c
    ../OBD_UI_Code/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../OBD_UI_Code/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../OBD_UI_Code/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../OBD_UI_Code/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
    ../OBD_UI_Code/: lv_port_disp.c
  group Touch
    ../Touch/: bsp_i2c_touch.c gt9xx.c
    ../OBD_UI_Code/: lv_port_indev.c
software components: CMSIS:CORE 4.3.0
